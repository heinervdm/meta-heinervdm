inherit qt4e

require qtserialport.inc

SRCREV = "29e526ad5c1e2fe0996ba0a776d83ec86f7197d7"

