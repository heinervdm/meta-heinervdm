TOBUILD := "src/tools/bootstrap \
            src/declarative \
            src/phonon \
            ${TOBUILD} \
           "

